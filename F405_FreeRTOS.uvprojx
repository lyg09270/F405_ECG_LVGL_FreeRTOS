# Keil uVision project F405_FreeRTOS.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F405_FreeRTOS
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-nan-infinity-disabled
  c include: .\Hardware;.\UI;.\User;.\nnom_lib\inc;.\nnom_lib\inc\layers;.\nnom_lib\port;.\nn
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Hardware
    ./Hardware/: lcd.c lcd.h ads1292.c ads1292.h
  group :CubeMX:CubeMX
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: main.c gpio.c adc.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c usart.c dma.c spi.c tim.c
    ./STM32CubeMX/Target_1/STM32CubeMX/MDK-ARM/: startup_stm32f405xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/Target_1/STM32CubeMX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group UI
    ./UI/: ui.c ui.h ui_comp_hook.c ui_events.h ui_font_Font1.c ui_helpers.c ui_helpers.h ui_Screen1.c ui_Screen2.c ui_img_568960143.c ui_events.c ui_Screen3.c ui_Screen4.c ui_Screen5.c
  group User
    ./User/: slide_window.c slide_window.h app.c app.h filter.c filter.h ecg.c ecg.h
  group nnom
    ./nnom_lib/inc/: nnom.h nnom_layers.h nnom_local.h nnom_tensor.h nnom_utils.h
    ./nnom_lib/inc/layers/: nnom_activation.h nnom_avgpool.h nnom_baselayer.h nnom_concat.h nnom_conv2d.h nnom_conv2d_trans.h nnom_cropping.h nnom_dense.h nnom_dw_conv2d.h nnom_flatten.h nnom_global_pool.h nnom_gru_cell.h nnom_input.h nnom_lambda.h nnom_lstm_cell.h nnom_matrix.h nnom_maxpool.h nnom_output.h nnom_reshape.h nnom_rnn.h nnom_simple_cell.h nnom_softmax.h nnom_sumpool.h nnom_upsample.h nnom_zero_padding.h
    ./nnom_lib/port/: nnom_port.h
    ./nnom_lib/src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_reshape.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
    ./nnom_lib/src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
    ./nnom_lib/src/backends/: nnom_local.c nnom_local_q15.c
    ./nn/: weights.h
software components: CMSIS:CORE 6.0.0, CMSIS:DSP 1.16.2, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.1.0, RTOS:Config 11.1.0, RTOS:Core 11.1.0, RTOS:Coroutines 11.1.0, RTOS:Event Groups 11.1.0, RTOS:Heap 11.1.0, RTOS:Message Buffer 11.1.0, RTOS:Stream Buffer 11.1.0, RTOS:Timers 11.1.0, Device:CubeMX 1.0.0, LVGL:Essential 9.2.2, LVGL:Porting:Display 9.2.2, LVGL:Porting:Input 9.2.2
